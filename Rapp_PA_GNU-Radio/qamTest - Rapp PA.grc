options:
  parameters:
    generate_options: qt_gui
    id: default
    output_language: python
    title: QAM
  states: {}

blocks:
- name: excess_bw
  id: variable
  parameters:
    comment: '[excessive bandwidth] for cosine filter'
    value: '0.35'
  states: {}
- name: nfilts
  id: variable
  parameters:
    comment: The [number] of [Synchronized Filter Bank]
    value: '32'
  states: {}
- name: qam16
  id: variable_constellation
  parameters:
    precision: '8'
    type: 16qam
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1, sps, 1, excess_bw, 45)
  states: {}
- name: rrc_taps_sync
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), excess_bw, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: 采样率（32ksps）
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: The [number of samples] for every symbol
    value: '4'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1024'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_throttle_0_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_constellation_modulator_0_0_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: qam16
    differential: 'False'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_pfb_clock_sync_xxx_0_1_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 6.28/100.0
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps_sync
    type: ccf
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    A_sat: '1.0'
    _source_code: |
      """
      Embedded Python Blocks:
       
      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block"
          """
          Simple Rapp model PA:
              y = x / (1 + (|x|/A_sat)^(2*p))^(1/(2*p))
          When p → ∞ 就变成硬限幅；p 越小转折越圆滑
          """
          def __init__(self, A_sat=1.0, p=2.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='PA_model_Rapp',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.A_sat = A_sat
              self.p = p

          def work(self, input_items, output_items):
              x = input_items[0]
              y = x / (1.0 + (np.abs(x)/self.A_sat)**(2.0*self.p))**(1.0/(2.0*self.p))
              output_items[0][:] = y
              return len(output_items[0])
    p: '3'
  states: {}
- name: fir_filter_xxx_0_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: rrc_taps
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_0_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 3,2,1,1
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.5'
    alpha2: '0.5'
    grid: 'True'
    gui_hint: 3,0,1,2
    label1: ''
    label2: ''
    name: '"QAM16"'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}

connections:
- [analog_random_source_x_0, '0', digital_constellation_modulator_0_0_0_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_float_to_complex_0, '1']
- [blocks_complex_to_mag_1, '0', blocks_float_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_throttle_0_0_0_0, '0', digital_pfb_clock_sync_xxx_0_1_0, '0']
- [blocks_throttle_0_0_0_0, '0', fir_filter_xxx_0_0_0_0, '0']
- [blocks_throttle_0_0_0_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_constellation_modulator_0_0_0_0, '0', blocks_complex_to_mag_1, '0']
- [digital_constellation_modulator_0_0_0_0, '0', epy_block_0, '0']
- [digital_pfb_clock_sync_xxx_0_1_0, '0', qtgui_const_sink_x_0_0_0_0, '0']
- [epy_block_0, '0', blocks_complex_to_mag_0, '0']
- [epy_block_0, '0', blocks_throttle_0_0_0_0, '0']
- [fir_filter_xxx_0_0_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
